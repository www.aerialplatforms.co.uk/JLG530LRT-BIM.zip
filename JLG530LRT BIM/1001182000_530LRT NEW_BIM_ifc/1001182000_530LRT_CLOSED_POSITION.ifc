Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-03-19T12:08:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 19 12:08:39 2018 * Host: CHTSP10141 * Database: C:\Users\20062089\AppData\Local\Temp\{E8070C73-4D83-4A82-A095-6FBEB457BCD6}\ifc * Database version: 5507 * Database creation date: Mon Mar 19 12:08:35 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 19 12:08:36 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 19 12:08:36 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcTransportElement: Flat Surface, 1001182000_530LRT:Flat Surface:1217646
In: Level 1
Type - PredefinedType: ELEVATOR; Material: JLG_Metal Paint_Grey, JLG_Paint_Black, JLG_Plastic_Red, JLG_Paint_Orange, JLG_Paint_White, JLG_Paint_Beige, JLG_Steel, JLG_Rubber_Black
Type - Constraints - Height: -1015 mm; Ht: 1174 mm; Offset: 2189 mm; Platform_Extention: 0 mm; Platform_Extention Maximum: User to define Extension; Platform_Height: 0 mm; Platform Height Maximum: User to define Height; PX: 0 mm; Slope Value: 0 deg; Slope Value Maximum: User to define Slope; Static: 1015 mm; Transportation Condition: no
Type - Data - Axle Oscillation: 0.20 m (0 ft 8 in); Diesel Engine: Kubota D1305-E3B; Drive Speed Elevator: 0.8 kph (0.5 mph); Drive Speed lowered: 5.6 kph (3.5 mph); Dual Fuel Engine: Kubota WG972-GL-E4F; Fuel Tank Capacity: 83.3 L (22 gal); Gradeability: 40%; Gross Vehicle Weight (ANSI): 7970 kg (17570 lbs); Gross Vehicle Weight (CE): 7970 kg (17570 lbs); Ground Clearance: 0.30 m (1 ft 0 in); Hydraulic Tank Capacity: 122.27 L (32.3 gal); Lift Up time: 59 sec; Lower down Time: 55 sec; Max Ground Bearing Pressure (ANSI): 1.86 kg/cm2 (26.5 psi); Max Ground Bearing Pressure (CE): 1.86 kg/cm2 (26.5 psi); Model Name: 530 LRT; Platform Capacity (ANSI): 680 kg (1500 lbs); Platform Capacity (CE): 680 kg (1500 lbs); Platform Extention Capacity (ANSI): 230 kg (500 lbs); Platform Extention Capacity (CE): 230 kg (500 lbs); Platform Extention Size (L): 1.14 m (3 ft 9 in); Platform Height: 16.15 m (53 ft 0 in); Platform Size (W x L): 1.91 m x 3.98 m (6 ft 3 in x 13 ft 1 in); Turning Radius Inside: 4.03m (13 ft 3 in); Turning Radius Outside: 6.02 m (19 ft 9 in); Tyres: 12x16.5 foam filled
Type - Dimensions - F: no; L: no; L_Height: 0 mm; Leg1: 0 mm; Leg2: 0 mm; Leg3: 0 mm; Leg4: 0 mm; Length: 0 mm; Offset Height: 0 mm; Offset Length: 0 mm; R: no; Re: no; Slope: 0 deg
Type - General - Platform Extention Size (Inside): 1.14 m (3 ft 9 in); Platform Size (Iinside): 1.91 m x 3.98 m (6 ft 3 in x 13 ft 1 in)
Type - Identity Data - Manufacturer: JLG; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: Flat Surface; URL: https://www.jlg.com
Type - Model Properties - _Author: n/a; _AuthorizedBy: n/a; _BIMspec_GUID: n/a; _BimSpecGuid: n/a; _BSBibleVersion: n/a; _CreatedBy: JLG; _CurrentRevision: 0; _DistributedBy: JLG; BIMObjectName: 1001182000_530LRT; NBSDescription: Engine Powered Scissor Lift; NBSNote: n/a; NBSObjectName: JLG_530LRT_Scissor Lift; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Mechanical Equipment; AccessibilityPerformance: n/a; AssetIdentifier (default): Please Record On Commissioning.; AssetType: Elevators; BarCode (default): Please Record On Commissioning.; ClassificationName: n/a; ClassificationValue: n/a; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: JLG (https://www.jlg.com/en); CreatedOn: 2018; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: 1001182000_530LRT; Features: n/a; Finish: n/a; Grade: n/a; InstallationDate (default): n/a; ManufacturerName: JLG (https://www.jlg.com/en); Material: n/a; ModelNumber: 530LRT; ModelReference: JLG_Engine Powered Scissor Lift; ProductionYear: n/a; ReferencedStandard: n/a; ReplacementCost: n/a; SerialNumber (default): n/a; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.jlg.com; WarrantyGuarantorParts: https://www.jlg.com
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG_Engine Powered Scissor Lift; Manufacturer: JLG; ProductionYear: n/a
Constraints - BWA: no; Extension Working Area: no; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; Turning Radius: no; Working Area: no
Dimensions - Area: 218.835 m2; Volume: 3.21427 m3
Identity Data - Mark: 53
Other - Family: 1001182000_530LRT: Flat Surface; Family and Type: 1001182000_530LRT: Flat Surface; Type: 1001182000_530LRT: Flat Surface; Type Id: 1001182000_530LRT: Flat Surface; WarrantyStartDate (default): Please Record On Commissioning.
Phasing - Phase Created: Phase 1
